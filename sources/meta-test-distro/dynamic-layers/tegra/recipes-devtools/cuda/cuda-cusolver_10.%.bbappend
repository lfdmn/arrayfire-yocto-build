RDEPENDS_${PN} += " \
    add-cuda-to-libpath \
"
